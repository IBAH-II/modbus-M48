# IAR project modbus.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x60
  General.SCRStackSize: 32
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm48.xcl
  group (top)
    ./: main.c modbus.c ModBus2Prg.c systimer.asm uart.asm
  group INC
    ./: main.h modbus.h systimer.h uart.h
  group list
    Release/List/: modbus.map
