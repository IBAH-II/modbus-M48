# IAR project Stend.ewp, settings and files
configuration Stend (ARM, debug)
  General.OGChipSelectEditMenu: STM32L052C8 ST STM32L052C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32L052xx
  ICCARM.CCIncludePath2: ../Inc; ../Src; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Stend.hex
  ILINK.IlinkOutputFile: Stend.out
  ILINK.IlinkIcfFile: stm32l052xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l052xx.s
  group Application/HID
    ../Inc/: ioport.h main.h modbus.h uart0.h wait.h
  group Application/HID_CM
    ../Drivers/CMSIS/Include/: core_cm0.h core_cm0plus.h
  group Application/HID_LL
    ../Drivers/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_ll_adc.h stm32l0xx_ll_bus.h stm32l0xx_ll_comp.h stm32l0xx_ll_cortex.h stm32l0xx_ll_crc.h stm32l0xx_ll_crs.h stm32l0xx_ll_dac.h stm32l0xx_ll_dma.h stm32l0xx_ll_exti.h stm32l0xx_ll_gpio.h stm32l0xx_ll_i2c.h stm32l0xx_ll_iwdg.h stm32l0xx_ll_lptim.h stm32l0xx_ll_lpuart.h stm32l0xx_ll_pwr.h stm32l0xx_ll_rcc.h stm32l0xx_ll_rng.h stm32l0xx_ll_rtc.h stm32l0xx_ll_spi.h stm32l0xx_ll_system.h stm32l0xx_ll_tim.h stm32l0xx_ll_usart.h stm32l0xx_ll_utils.h stm32l0xx_ll_wwdg.h
  group Application/User
    ../Src/: main.c modbus.c ModBus2Prg.c stm32l0xx_it.c SysConfig.c uart0.c wait.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_dma.c stm32l0xx_ll_gpio.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_tim.c stm32l0xx_ll_utils.c
